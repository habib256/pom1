/* ===========================================================================
 * t41_c_sprmask.c — micro-test: gen2c masked sprite kernels ON-TARGET
 * ===========================================================================
 * GUARDS gen2_sprmask.s (the SPRMASK family under the sprite engine) after its
 * rewrite to down-counting loops, a setup that skips the product at phase 0
 * and the data/mask pointers for save/restore, unrolled widths 2 and 4, and a
 * right clip against the columns left (no overflowing sum).
 *
 * Three random 7-phase banks (stride 3 x h 5, 2 x 4, 4 x 6; mask bit 7 set,
 * data bit 7 clear) over a non-uniform page-1 background:
 *   msu  s3 (10,20)   phase 3, generic width 3
 *   msu  s2 (56,40)   phase 0 (no product), unrolled width 2
 *   msu  s4 (263,189) x >= 256 (col 37, phase 4), right-clipped to 3,
 *                     bottom-clipped to 3 rows
 *   msu  s4 (100,100) phase 2, unrolled width 4
 *   msu  s3 (279,0)   col 39, right-clipped to 1
 *   ms_run  s2 (200,150)   draw without save
 *   ms_save s3 (150,60)    save without draw
 * then every saved rectangle is restored, in reverse.
 * Expected values from a Python model of the kernels' maths; the kernels as
 * they were before the rewrite pass this test too.
 *
 * Mailbox at $1000:  +0 magic $A5
 *   +1/+2 background page sum   +3/+4 page sum after the draws
 *   +5/+6 sum of the six under-buffers   +7/+8 page sum after the restores
 *
 * POM1-LIB-MICRO-TEST
 * MODE: gen2
 * LIBS: gen2c/gen2_init.c gen2c/gen2_tables.s gen2c/gen2_page.s gen2c/gen2_mode_asm.s gen2c/gen2_hgr_clear_asm.s gen2c/gen2_sprmask.s apple1c/apple1io_asm.s apple1c/apple1io_str.s apple1c/apple1io_key.s
 * CFG: ../cc65/apple1_gen2_c.cfg
 * PRESET: 11
 * LOAD: 6000
 * RUN: 6000
 * STEPS: 4000000
 * EXPECT: 1000 A5 00 EF 23 F9 B9 2B 8F F0
 * =========================================================================== */

#include "gen2.h"
#include "gen2_internal.h"

#define MB ((volatile unsigned char *)0x1000)

static const unsigned char s3_d[] = {0x1E,0x51,0x1A,0x39,0x6B,0x7D,0x70,0x3D,0x00,0x14,0x1C,0x49,0x19,0x73,0x02,0x7D,0x50,0x35,0x65,0x40,0x59,0x5B,0x60,0x13,0x57,0x16,0x4A,0x49,0x75,0x24,0x4F,0x06,0x5E,0x5D,0x76,0x6C,0x17,0x66,0x7F,0x1D,0x6C,0x7D,0x65,0x42,0x6B,0x7A,0x06,0x39,0x21,0x0C,0x1A,0x6D,0x78,0x24,0x7B,0x3A,0x1F,0x74,0x78,0x40,0x66,0x4E,0x7A,0x66,0x6E,0x33,0x4B,0x44,0x02,0x08,0x26,0x75,0x7D,0x5C,0x33,0x42,0x7C,0x77,0x7F,0x6F,0x08,0x4A,0x51,0x75,0x19,0x70,0x42,0x73,0x2E,0x6C,0x7A,0x10,0x44,0x7F,0x5E,0x18,0x31,0x69,0x25,0x73,0x03,0x17,0x00,0x73,0x15};
static const unsigned char s3_m[] = {0xB2,0xBF,0x9E,0x8B,0xC4,0xDB,0xA7,0x81,0xD0,0xFD,0xA2,0xB9,0xF9,0xA1,0xCA,0x95,0xEA,0xA8,0xA2,0xCE,0xE9,0xE3,0xA6,0xB2,0xE0,0x83,0x9B,0xE3,0x92,0x8D,0xD8,0xDA,0x86,0x86,0xF9,0xD3,0xCD,0xF3,0xD3,0x9F,0xFF,0xF7,0xAB,0xA7,0xB4,0xEF,0xD6,0xF5,0xBB,0x91,0xE6,0x88,0xB2,0xAC,0x8B,0x8C,0xF3,0xB0,0xFB,0x85,0xA1,0xB7,0xA3,0xA9,0xAF,0xE3,0xC5,0xEC,0xEA,0x94,0xE2,0xCE,0xAF,0xD8,0xAC,0xC3,0xF6,0xFF,0xEA,0xC9,0xF7,0xAD,0xD3,0xFB,0xF1,0x9E,0xC6,0x98,0xB6,0xBB,0x81,0x97,0xF4,0xD4,0xE8,0xAE,0x86,0xDA,0xA8,0xDA,0xB7,0x9C,0xC7,0xB6,0xCB};
static const unsigned char s2_d[] = {0x44,0x21,0x19,0x43,0x18,0x6F,0x2B,0x1B,0x0F,0x5B,0x2F,0x1B,0x50,0x46,0x10,0x4A,0x50,0x29,0x42,0x41,0x10,0x03,0x69,0x41,0x6A,0x03,0x0E,0x18,0x3C,0x05,0x4F,0x1F,0x18,0x59,0x50,0x74,0x09,0x67,0x50,0x37,0x76,0x6D,0x1E,0x5F,0x40,0x63,0x4A,0x5B,0x0E,0x6F,0x06,0x48,0x54,0x4A,0x1F,0x4C};
static const unsigned char s2_m[] = {0xEA,0xD1,0x85,0xD7,0xB2,0x8E,0x9C,0xA9,0x9F,0x9E,0x89,0xA0,0xDA,0xCD,0x87,0xEC,0xA0,0xDB,0xEA,0xE2,0xE0,0xBD,0xEB,0xB8,0xA0,0xAE,0x87,0xE5,0xC1,0xA5,0xBA,0x85,0x84,0xC6,0xFA,0xEA,0xC3,0xD0,0xA3,0x96,0xAD,0x89,0xC3,0xD7,0xD1,0x8E,0x82,0xBE,0xF8,0x8E,0xB8,0xA6,0xE6,0xDC,0xBB,0xC6};
static const unsigned char s4_d[] = {0x57,0x33,0x5F,0x5B,0x75,0x75,0x79,0x4F,0x30,0x28,0x69,0x27,0x7C,0x01,0x5A,0x68,0x09,0x2C,0x15,0x4C,0x5F,0x43,0x23,0x19,0x04,0x37,0x4E,0x0B,0x64,0x61,0x28,0x1A,0x15,0x24,0x63,0x55,0x42,0x4F,0x0A,0x30,0x29,0x4A,0x4B,0x49,0x5B,0x22,0x63,0x30,0x02,0x7A,0x6C,0x5B,0x2B,0x07,0x2D,0x50,0x25,0x29,0x07,0x1D,0x00,0x5F,0x10,0x5E,0x4D,0x37,0x27,0x3F,0x20,0x1B,0x53,0x7C,0x1B,0x12,0x61,0x43,0x4D,0x1E,0x59,0x79,0x7F,0x1E,0x3F,0x5B,0x74,0x58,0x15,0x11,0x16,0x7E,0x4F,0x43,0x39,0x2B,0x53,0x6E,0x54,0x52,0x7E,0x67,0x50,0x2D,0x32,0x76,0x38,0x59,0x59,0x68,0x61,0x36,0x27,0x71,0x20,0x6E,0x44,0x54,0x1E,0x51,0x44,0x71,0x43,0x25,0x44,0x3B,0x54,0x24,0x1F,0x44,0x4B,0x75,0x66,0x66,0x05,0x54,0x68,0x56,0x18,0x7E,0x35,0x6C,0x5A,0x54,0x0F,0x66,0x2C,0x02,0x44,0x40,0x21,0x55,0x6A,0x79,0x7B,0x56,0x03,0x09,0x38,0x1E,0x44,0x53,0x04,0x35,0x75,0x46,0x5E,0x14,0x30,0x02};
static const unsigned char s4_m[] = {0x98,0xA7,0xD4,0xB8,0xF6,0xB4,0xAB,0xCF,0x95,0xEA,0xA2,0x9B,0x87,0xC5,0xEB,0x8B,0xAF,0xBB,0xF8,0xD7,0xD7,0xD8,0xD1,0xFA,0xC1,0xFD,0xD3,0xC0,0x89,0xFD,0xA2,0x85,0xFB,0xDD,0xC0,0xF7,0xB2,0xDE,0xC6,0xE6,0xCD,0xB7,0x8D,0xE9,0x90,0xCC,0xFB,0x97,0xD3,0xFD,0xD1,0xD6,0xDC,0xAE,0x93,0xAC,0xC1,0xE2,0x9B,0xB6,0x87,0xF6,0xBD,0xB5,0xED,0xA0,0xB6,0xC5,0xFD,0xA2,0xD3,0xDD,0xE4,0xB0,0xA6,0xA7,0xA4,0xA1,0x8F,0x88,0xC7,0xCC,0xAD,0xA3,0xC4,0xDB,0xA0,0xF5,0xAB,0xAF,0x8D,0xAF,0xA7,0xE9,0xFD,0x87,0xCC,0xB8,0xDD,0x97,0xF7,0xE8,0xA7,0xD3,0xA5,0x8A,0xF8,0x81,0x8E,0x98,0xDA,0xC1,0xD4,0x87,0xA9,0xB0,0x97,0xEC,0xEE,0xB3,0xAB,0xBD,0xB9,0xFE,0xB6,0xDF,0xA8,0xEC,0xEC,0xF5,0xDC,0xB5,0xCF,0xF0,0xFB,0x97,0xB6,0xB2,0x9D,0x94,0xDA,0xA8,0x9D,0xAC,0xB4,0xEE,0xB0,0xED,0x87,0xA5,0xC4,0xC9,0xDD,0xE5,0x82,0xFA,0xF5,0xC5,0xDA,0xFC,0xA3,0x9B,0xA4,0xB8,0xDB,0xF4,0xE0,0x8C};

static const gen2_mspr_t s3 = { s3_d, s3_m, 3u, 5u };
static const gen2_mspr_t s2 = { s2_d, s2_m, 2u, 4u };
static const gen2_mspr_t s4 = { s4_d, s4_m, 4u, 6u };
static unsigned char U[6][24];

static unsigned page_sum(void)
{
    register const unsigned char *p = GEN2_HGR1;
    unsigned s = 0u;
    unsigned char k, i;
    for (k = 0u; k < 32u; ++k) {
        i = 0u;
        do { s += p[i]; } while (++i != 0u);
        p += 256;
    }
    return s;
}

static unsigned under_sum(void)
{
    unsigned s = 0u;
    unsigned char i;
    const unsigned char *u = &U[0][0];
    for (i = 0u; i < sizeof U; ++i) s += u[i];
    return s;
}

/* Mailbox stores go through a function: inline after a loop that used ptr1,
 * cc65 -Oirs reused a stale ptr1 for MB and wrote the result INTO U[5]. */
static void out16(unsigned char at, unsigned v)
{
    MB[at] = (unsigned char)v;
    MB[at + 1u] = (unsigned char)(v >> 8);
}

static void put(unsigned x, unsigned char y, const gen2_mspr_t *s, unsigned char u)
{
    gen2_ms_x = x; gen2_ms_y = y; gen2_ms_spr = s; gen2_ms_under = U[u];
}

void main(void)
{
    unsigned char y, c;
    unsigned char *row;

    gen2_hgr_init();
    gen2_set_draw_page(1u);              /* builds the tables */
    gen2_hgr_clear(0u);
    for (y = 0u; y < 192u; ++y) {
        row = gen2_hgr_row(y);
        for (c = 0u; c < 40u; ++c)
            row[c] = (unsigned char)(y * 7u + c * 13u);
    }
    out16(1u, page_sum());

    put( 10u,  20u, &s3, 0u); gen2_msu_run();
    put( 56u,  40u, &s2, 1u); gen2_msu_run();
    put(263u, 189u, &s4, 2u); gen2_msu_run();
    put(100u, 100u, &s4, 3u); gen2_msu_run();
    put(279u,   0u, &s3, 4u); gen2_msu_run();
    put(200u, 150u, &s2, 5u); gen2_ms_run();
    put(150u,  60u, &s3, 5u); gen2_ms_save_run();
    out16(3u, page_sum());
    out16(5u, under_sum());

    put(279u,   0u, &s3, 4u); gen2_ms_restore_run();
    put(100u, 100u, &s4, 3u); gen2_ms_restore_run();
    put(263u, 189u, &s4, 2u); gen2_ms_restore_run();
    put( 56u,  40u, &s2, 1u); gen2_ms_restore_run();
    put( 10u,  20u, &s3, 0u); gen2_ms_restore_run();
    put(150u,  60u, &s3, 5u); gen2_ms_restore_run();
    out16(7u, page_sum());
    MB[0] = 0xA5u;                       /* magic LAST */
    for (;;) { }
}
