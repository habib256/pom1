; =============================================
; hgr_plot_tables.inc - HGR per-pixel column/mask tables
; =============================================
; hgr_col[x]  = x / 7          -> byte column
; hgr_mask[x] = 1 << (x mod 7) -> pixel bitmask
; for x = 0..255 (512 bytes), generated by .repeat (byte-identical to the
; hand-typed tables they replaced). Used by plot_pixel (hgr_plot.asm).
;
; Options (define BEFORE the include; zero or undefined = the default):
;   HGR_FULL_WIDTH_TABLES = 1  columns 0..279 instead of 0..255 (+48 B);
;                              required by hgr_plot16 / hgr_line16.
;   HGR_PLOT_TABLES_RAM = 1    the tables are reserved in segment "BSS"
;                              (the program's cfg must declare one) instead
;                              of stored in the file, and hgr_plot_tables_init
;                              (25 B, 45 B full width; assembled in the current
;                              segment) fills them: call it once before any
;                              plot. The loaded file shrinks by 487 B (512 -
;                              25; 515 B full width), a faster tape load;
;                              ~7 400 cycles once (~8 300 full width).
;                              Clobbers A, X, Y.
; HGR_PLOT_COLUMNS is defined (256 or 280) for the modules that check it.
;
; Option names and the RAM builder are ported from the pom2games Apple II
; edition (lib/hgr/hgr_plot_tables.inc); the HGR layout is the same.
; =============================================

.ifndef _HGR_PLOT_TABLES_LOADED_
_HGR_PLOT_TABLES_LOADED_ = 1

.ifndef HGR_FULL_WIDTH_TABLES
HGR_FULL_WIDTH_TABLES = 0
.endif
.ifndef HGR_PLOT_TABLES_RAM
HGR_PLOT_TABLES_RAM = 0
.endif
.if HGR_FULL_WIDTH_TABLES
HGR_PLOT_COLUMNS = 280
.else
HGR_PLOT_COLUMNS = 256
.endif
.ifdef _HGR_PLOT16_LOADED_              ; hgr_plot16 reads columns 256..279
.assert HGR_PLOT_COLUMNS = 280, error, "hgr_plot16 needs HGR_FULL_WIDTH_TABLES = 1 (columns 256..279)"
.endif

.if HGR_PLOT_TABLES_RAM
.pushseg
.segment "BSS"
hgr_col:  .res HGR_PLOT_COLUMNS
hgr_mask: .res HGR_PLOT_COLUMNS
.popseg
; One step of the fill: A = mask, Y = column, X = x (low byte).
.macro HGR_PLOT_TABLES_STEP base
        STA     hgr_mask+base,X
        PHA
        TYA
        STA     hgr_col+base,X
        PLA
        ASL     A
        BPL     :+                      ; $80: past bit 6, next byte column
        LDA     #1
        INY
:       INX
.endmacro
hgr_plot_tables_init:
        LDA     #1
        LDX     #0
        LDY     #0
@lo:    HGR_PLOT_TABLES_STEP 0
        BNE     @lo
.if HGR_PLOT_COLUMNS > 256
@hi:    HGR_PLOT_TABLES_STEP 256
        CPX     #HGR_PLOT_COLUMNS-256
        BNE     @hi
.endif
        RTS
.else
; --- hgr_col[]: x / 7 -> byte column ---
hgr_col:
        .repeat HGR_PLOT_COLUMNS, col
        .byte col / 7
        .endrepeat
; --- hgr_mask[]: 1 << (x % 7) -> pixel bitmask ---
hgr_mask:
        .repeat HGR_PLOT_COLUMNS, col
        .byte 1 << (col .mod 7)
        .endrepeat
.endif

.endif  ; _HGR_PLOT_TABLES_LOADED_
